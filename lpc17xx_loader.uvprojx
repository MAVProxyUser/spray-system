# Keil uVision project lpc17xx_loader.uvprojx, settings and files
target lpc17xx_usb_loader_release (ARM-ADS)
  device: LPC1765 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x3FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: w610_usb_loader_release +hex
  c flags: Optim=3
  c define: __USB__
  asm misc: --cpreproc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x7f60
  memory RVCT10: RAM 0x2007c000 size 0x8000
  scatter file: .\scatter\Lpc1765_IAP_loader.sct
  group Cstartup
    ./cstartup/: core_cm3.c system_LPC17xx.c startup_LPC17xx.s type.h
  group App
    ./app/: main.c
  group App/aes
    ./app/aes/: aes.c
  group App/crc
    ./app/crc/: MF_CRC8.c MF_CRC16.c
  group App/cfg
    ./app/cfg/: cfg_inc.h cfg_unpack.h cfg_unpack.c cfg_handler.h cfg_handler.c cfg_decoder.c cfg_handler_a2.c
  group App/md5
    ./app/md5/: MF_MD5.h MF_MD5.c
  group App/cm_at88
    ./app/cm_at88/: cm_app.c cm_gpa.c cm_i2c.c cm_lib.c
  group Bsp
    ./bsp/: bsp.h libdef.h critical.asm bsp.c
  group IAP
    ./iap/: sbl_config.h sbl_iap.c sbl_iap.h
  group Drivers
    ./drivers/uart/: lpc17xx_uart.c
    ./drivers/wdt/: lpc17xx_wdt.c
    ./drivers/timer/: lpc17xx_timer.c
    ./drivers/adc/: lpc17xx_adc.c
    ./drivers/: drivers.h
  group Can
    ./can/: can_inc.h can_def.h can_ext_declares.h can_hw.h can_hw.c can_af.h can_af.c can_package.h can_package.c can_unpack.c
  group Usb
    ./usb/: cdcuser.c usb_composite_app.c usbcore.c usbdesc.c usbhw.c usbuser.c vcom_app.c vcom_buf.c mscuser.c
  group User
    ./drivers/: user_interrupt.c user_led.c user_pwm.c user_sensor.c
target lpc17xx_can_loader_release (ARM-ADS)
  device: LPC1765 NXP (founded by Philips)
  pack: Keil.LPC1700_DFP.2.3.0
  cpu: as above
  output: w610_can_loader_release +hex
  AfterMake: fromelf --bin .\Hex\w610_can_loader_release.axf -o .\Hex\w610_can_loader_release.bin
  c flags: Optim=3
  c define: __CAN__
  asm misc: --cpreproc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x7f60
  memory RVCT10: RAM 0x2007c000 size 0x8000
  scatter file: .\scatter\Lpc1765_IAP_loader.sct
target lpc17xx_usb_loader_debug (ARM-ADS)
  device: LPC1765 NXP (founded by Philips)
  cpu: as above
  output: w610_usb_loader_debug +hex
  c flags: Optim=3 wLevel=2
  c define: __DEBUG_UART0_PRINTF__,__USB__
  asm define: NO_CRP
  asm misc: --cpreproc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x7f60
  memory RVCT10: RAM 0x2007c000 size 0x8000
  scatter file: .\scatter\Lpc1765_IAP_loader.sct
target lpc17xx_can_loader_debug (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: LPC1765 NXP
  pack: Keil.LPC1700_DFP.2.3.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Farming_app_debug
  AfterMake: fromelf --bin .\output\Farming_app_debug.axf -o .\output\Farming_app_debug.bin
  c flags: Optim=1
  c define: __DEBUG_UART2_PRINTF__,__UART0__,__UART1__,__UART2__,__UART3__,__UART2_ENABLE__,__UART3_ENABLE__,__UART0_ENABLE__,__UART1_ENABLE__
  c include: .\cstartup;.\drivers\uart;.\app\cfg;.\iap;.\drivers;.\usb;.\drivers\adc;.\drivers\gpio;.\drivers
  asm define: NO_CRP
  asm misc: --cpreproc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x7f60
  memory RVCT10: RAM 0x2007c000 size 0x8000
  scatter file: .\scatter\Lpc1765_IAP_loader.sct
